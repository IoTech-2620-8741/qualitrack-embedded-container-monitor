/**
 * @file ContainerDisplay.cpp
 * @brief Implements the screen of the Container Monitor on an SSD1306.
 */
#include "ContainerDisplay.h"
#include <Wire.h>
#include <cmath>
#include <cstdio>
#include <cstring>

namespace {
    /// Vertical position of each line of the data screen (7 px font).
    constexpr uint8_t LINE_Y[] = {0, 13, 23, 33, 45, 55};
    /// Vertical position of the separators of the data screen.
    constexpr uint8_t SEPARATOR_Y[] = {10, 42};
    constexpr uint8_t CHARACTER_WIDTH = 6;
    constexpr uint8_t FIRST_CHARACTER = 0x20;
    constexpr uint8_t LAST_CHARACTER = 0x7E;
    /// Data bytes per I2C transaction, well inside the 128-byte buffer of the ESP32 Wire library.
    constexpr size_t DATA_CHUNK_SIZE = 16;

    /// 5x7 ASCII font (0x20-0x7E), one byte per column with the top row in bit 0 (the font of the framework).
    constexpr uint8_t FONT[][5] = {
        {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},{0x14,0x7F,0x14,0x7F,0x14},
        {0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x55,0x22,0x50},{0x00,0x05,0x03,0x00,0x00},
        {0x00,0x1C,0x22,0x41,0x00},{0x00,0x41,0x22,0x1C,0x00},{0x14,0x08,0x3E,0x08,0x14},{0x08,0x08,0x3E,0x08,0x08},
        {0x00,0x50,0x30,0x00,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x60,0x60,0x00,0x00},{0x20,0x10,0x08,0x04,0x02},
        {0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},{0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4B,0x31},
        {0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
        {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1E},{0x00,0x36,0x36,0x00,0x00},{0x00,0x56,0x36,0x00,0x00},
        {0x08,0x14,0x22,0x41,0x00},{0x14,0x14,0x14,0x14,0x14},{0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x51,0x09,0x06},
        {0x32,0x49,0x79,0x41,0x3E},{0x7E,0x11,0x11,0x11,0x7E},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
        {0x7F,0x41,0x41,0x22,0x1C},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},{0x3E,0x41,0x49,0x49,0x7A},
        {0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},{0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},
        {0x7F,0x40,0x40,0x40,0x40},{0x7F,0x02,0x0C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
        {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},{0x46,0x49,0x49,0x49,0x31},
        {0x01,0x01,0x7F,0x01,0x01},{0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},
        {0x63,0x14,0x08,0x14,0x63},{0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43},{0x00,0x7F,0x41,0x41,0x00},
        {0x02,0x04,0x08,0x10,0x20},{0x00,0x41,0x41,0x7F,0x00},{0x04,0x02,0x01,0x02,0x04},{0x40,0x40,0x40,0x40,0x40},
        {0x00,0x01,0x02,0x04,0x00},{0x20,0x54,0x54,0x54,0x78},{0x7F,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20},
        {0x38,0x44,0x44,0x48,0x7F},{0x38,0x54,0x54,0x54,0x18},{0x08,0x7E,0x09,0x01,0x02},{0x18,0xA4,0xA4,0xA4,0x7C},
        {0x7F,0x08,0x04,0x04,0x78},{0x00,0x44,0x7D,0x40,0x00},{0x20,0x40,0x44,0x3D,0x00},{0x7F,0x10,0x28,0x44,0x00},
        {0x00,0x41,0x7F,0x40,0x00},{0x7C,0x04,0x18,0x04,0x78},{0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},
        {0xFC,0x24,0x24,0x24,0x18},{0x18,0x24,0x24,0x18,0xFC},{0x7C,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x20},
        {0x04,0x3F,0x44,0x40,0x20},{0x3C,0x40,0x40,0x20,0x7C},{0x1C,0x20,0x40,0x20,0x1C},{0x3C,0x40,0x30,0x40,0x3C},
        {0x44,0x28,0x10,0x28,0x44},{0x0C,0x50,0x50,0x50,0x3C},{0x44,0x64,0x54,0x4C,0x44},{0x00,0x08,0x36,0x41,0x00},
        {0x00,0x00,0x7F,0x00,0x00},{0x00,0x41,0x36,0x08,0x00},{0x10,0x08,0x08,0x10,0x08}
    };

    /// Setup of a 128x64 SSD1306 with its charge pump, each command with its arguments in one transaction.
    constexpr uint8_t SETUP[] = {
        0x00,       // Command stream
        0xAE,       // Display off
        0xD5, 0x80, // Clock divide ratio
        0xA8, 0x3F, // Multiplex ratio: 64 rows
        0xD3, 0x00, // No display offset
        0x40,       // Start line 0
        0x8D, 0x14, // Charge pump on
        0x20, 0x00, // Horizontal addressing
        0xA1,       // Segment remap
        0xC8,       // COM scan from the last row
        0xDA, 0x12, // COM pins of a 128x64 panel
        0x81, 0x7F, // Contrast
        0xD9, 0xF1, // Pre-charge period
        0xDB, 0x40, // VCOMH level
        0xA4,       // Show the RAM content
        0xA6,       // Normal (not inverted)
        0x2E,       // No scroll
        0xAF        // Display on
    };
}

ContainerDisplay::ContainerDisplay(const uint8_t i2cAddress)
    : i2cAddress(i2cAddress),
      frame{},
      lines{},
      shownLines{},
      accessShown(false),
      accessGranted(false),
      accessTag{},
      accessShownAt(0),
      framed(false),
      drawn(false) {}

bool ContainerDisplay::initialize() {
    Wire.beginTransmission(i2cAddress);
    Wire.write(SETUP, sizeof(SETUP));
    if (Wire.endTransmission() != 0) return false;
    sendFrame(); // Blank screen.
    return true;
}

void ContainerDisplay::showAccess(const bool granted, const char* tag, const unsigned long nowInMilliseconds) {
    accessShown = true;
    accessGranted = granted;
    accessShownAt = nowInMilliseconds;
    snprintf(accessTag, sizeof(accessTag), "%s", tag == nullptr ? "" : tag);
}

void ContainerDisplay::refresh(const ContainerSnapshot& snapshot, const unsigned long nowInMilliseconds) {
    if (accessShown && nowInMilliseconds - accessShownAt >= ACCESS_MESSAGE_DURATION_IN_MILLISECONDS) {
        accessShown = false;
    }
    if (accessShown) {
        composeAccess();
    } else {
        composeData(snapshot);
    }
    if (drawn && framed == accessShown && memcmp(lines, shownLines, sizeof(lines)) == 0) return; // Same screen.
    drawn = true;
    framed = accessShown;
    memcpy(shownLines, lines, sizeof(lines));
    draw();
}

void ContainerDisplay::composeData(const ContainerSnapshot& snapshot) {
    snprintf(lines[0], LINE_SIZE, "%-13.13s%8s", snapshot.deviceId, snapshot.overallState);
    composeMetric(1, "TEMP", "%5.1fC", snapshot.temperature);
    composeMetric(2, "HUM ", "%5.1f%%", snapshot.humidity);
    composeMetric(3, "LUX ", "%4.0flx", snapshot.luminosity);
    snprintf(lines[4], LINE_SIZE, "%s - %s", snapshot.action, snapshot.locked ? "LOCKED" : "OPEN");
    snprintf(lines[5], LINE_SIZE, "%-11s%10s", snapshot.link, snapshot.alarmAcknowledged ? "ALARM ACK" : "");
}

void ContainerDisplay::composeMetric(const size_t line, const char* label, const char* format,
                                     const MetricLine& metric) {
    char value[10];
    if (std::isnan(metric.value)) {
        snprintf(value, sizeof(value), "%6s", "--");
    } else {
        snprintf(value, sizeof(value), format, metric.value);
    }
    snprintf(lines[line], LINE_SIZE, "%s %-7s%8s", label, value, metric.state);
}

void ContainerDisplay::composeAccess() {
    snprintf(lines[0], LINE_SIZE, "%s", "");
    snprintf(lines[1], LINE_SIZE, "%s", "ACCESS");
    snprintf(lines[2], LINE_SIZE, "%s", accessGranted ? "GRANTED" : "DENIED");
    snprintf(lines[3], LINE_SIZE, "%s", accessTag);
    snprintf(lines[4], LINE_SIZE, "%s", accessGranted ? "OPENING..." : "STAYS LOCKED");
    snprintf(lines[5], LINE_SIZE, "%s", "");
}

void ContainerDisplay::draw() {
    memset(frame, 0, sizeof(frame));
    if (framed) {
        drawRectangle(0, 0, WIDTH, HEIGHT);
        // Centered lines inside the frame.
        for (size_t line = 1; line < LINE_COUNT - 1; ++line) {
            const size_t width = strlen(lines[line]) * CHARACTER_WIDTH;
            const uint8_t x = width < WIDTH ? static_cast<uint8_t>((WIDTH - width) / 2) : 0;
            drawText(lines[line], x, static_cast<uint8_t>(8 + (line - 1) * 12));
        }
    } else {
        for (size_t line = 0; line < LINE_COUNT; ++line) {
            drawText(lines[line], 0, LINE_Y[line]);
        }
        for (const uint8_t y : SEPARATOR_Y) {
            drawHorizontalLine(0, y, WIDTH);
        }
    }
    sendFrame();
}

void ContainerDisplay::setPixel(const uint8_t x, const uint8_t y) {
    if (x >= WIDTH || y >= HEIGHT) return;
    frame[(y / 8) * WIDTH + x] |= static_cast<uint8_t>(1 << (y % 8));
}

void ContainerDisplay::drawText(const char* text, uint8_t x, const uint8_t y) {
    for (; *text != '\0' && x + CHARACTER_WIDTH <= WIDTH + 1; ++text, x += CHARACTER_WIDTH) {
        const uint8_t character = static_cast<uint8_t>(*text);
        if (character < FIRST_CHARACTER || character > LAST_CHARACTER) continue;
        const uint8_t* glyph = FONT[character - FIRST_CHARACTER];
        for (uint8_t column = 0; column < 5; ++column) {
            for (uint8_t row = 0; row < 8; ++row) {
                if (glyph[column] & (1 << row)) setPixel(x + column, y + row);
            }
        }
    }
}

void ContainerDisplay::drawHorizontalLine(const uint8_t x, const uint8_t y, const uint8_t length) {
    for (uint8_t offset = 0; offset < length; ++offset) setPixel(x + offset, y);
}

void ContainerDisplay::drawRectangle(const uint8_t x, const uint8_t y, const uint8_t width, const uint8_t height) {
    drawHorizontalLine(x, y, width);
    drawHorizontalLine(x, y + height - 1, width);
    for (uint8_t offset = 0; offset < height; ++offset) {
        setPixel(x, y + offset);
        setPixel(x + width - 1, y + offset);
    }
}

void ContainerDisplay::sendFrame() const {
    // The whole screen as the drawing window, then the frame in small data transactions.
    static constexpr uint8_t WINDOW[] = {0x00, 0x21, 0x00, WIDTH - 1, 0x22, 0x00, HEIGHT / 8 - 1};
    Wire.beginTransmission(i2cAddress);
    Wire.write(WINDOW, sizeof(WINDOW));
    Wire.endTransmission();
    for (size_t offset = 0; offset < sizeof(frame); offset += DATA_CHUNK_SIZE) {
        Wire.beginTransmission(i2cAddress);
        Wire.write(0x40);
        Wire.write(frame + offset, DATA_CHUNK_SIZE);
        Wire.endTransmission();
    }
}
